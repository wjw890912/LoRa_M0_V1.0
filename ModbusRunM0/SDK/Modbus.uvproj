# Keil uVision project Modbus.uvproj, settings and files
target Modbus (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Modbus +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\chip_lib\CMSIS\Include;..\chip_lib\Device\Nuvoton\M051Series;..\chip_lib\Device\Nuvoton\M051Series\Source\ARM;..\user\inc;..\freemodbus-v1.6.0\port;..\freemodbus-v1.6.0\modbus\include;..\chip_lib\Device\Nuvoton\M051Series\Include;..\chip_lib\StdDriver\inc;..\freemodbus-v1.6.0\modbus\rtu;..\freemodbus-v1.6.0\modbus;..\HDT11;..\SI4432Protocol;..\SI4432_Driver;..\SI4432_Driver;..\sx12xxDrivers-V2.1.0\SX12xxDrivers-V2.1.0\src;..\sx12xxDrivers-V2.1.0\SX12xxDrivers-V2.1.0\src\platform\sx12xxEiger;..\sx12xxDrivers-V2.1.0\SX12xxDrivers-V2.1.0\src\radio;..\sx12xxDrivers-V2.1.0\SX12xxDrivers-V2.1.0\src\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group app
    ../user/src/: main.c
  group modbus/port
    ../freemodbus-v1.6.0/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
  group modbus/modbus/rtu
    ../freemodbus-v1.6.0/modbus/rtu/: mbcrc.c mbrtu.c
  group modbus/modbus/functions
    ../freemodbus-v1.6.0/modbus/functions/: btfunc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus/modbus/include
    ../freemodbus-v1.6.0/modbus/include/: mb.h mb_m.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/modbus/tcp
    ../freemodbus-v1.6.0/modbus/tcp/: mbtcp.c
  group modbus
    ../freemodbus-v1.6.0/modbus/: mb.c
  group chip_lib
    ../chip_lib/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group cpu
    ../chip_lib/CMSIS/Include/: core_cm0.h
    ../chip_lib/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    ../chip_lib/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group readme
    ./: readme.txt
  group realyctrl
    ../user/src/: realyctrl.c
  group uart
    ../user/src/: Uart3th.c
    ../user/inc/: Uart3th.h
  group dht11
    ../HDT11/: HDT11.c
  group si4432_dev
    ../SI4432_Driver/: SI4432.c SI4432RFConfig.c
  group gprs
    ../user/src/: GPRS_USR_GM3.c
  group blux_v30b
    ../user/src/: BLUX_V30B.C
  group fmc_data_flash
    ../user/src/: FMC_DATA_FLASH.C
  group lora/radio
    ../sx12xxDrivers-V2.1.0/SX12xxDrivers-V2.1.0/src/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group lora/main
    ../sx12xxDrivers-V2.1.0/SX12xxDrivers-V2.1.0/src/: loramain.c
  group lora/sx12xxEiger
    ../sx12xxDrivers-V2.1.0/SX12xxDrivers-V2.1.0/src/platform/sx12xxEiger/: sx12xxEiger.c sx1276-Hal.c
